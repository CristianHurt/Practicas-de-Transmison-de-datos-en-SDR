options:
  parameters:
    author: v-c
    generate_options: qt_gui
    id: QPSKPruebas1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bit_Rate
  id: variable
  parameters:
    comment: tasa de bits
    value: int(48e3)
  states: {}
- name: Bytes
  id: variable
  parameters:
    comment: Bytes a enviar
    value: int(Bit_Rate/8)
  states: {}
- name: CMA
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: Delay
  id: variable_qtgui_range
  parameters:
    min_len: '500'
    outputmsgname: value
    showports: 'False'
    start: '1'
    step: '1'
    stop: '1000'
    value: '190'
    widget: counter
  states: {}
- name: Frec_offset
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '-0.1'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    comment: '# Puntos de Constelacion'
    value: '4'
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: Symbol_Rate
  id: variable
  parameters:
    comment: tasa de simbolos
    value: Bit_Rate/bps
  states: {}
- name: Time_BW
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: 2*3.141592/100
  states: {}
- name: bps
  id: variable
  parameters:
    comment: Bits por simbolo
    value: math.log(M,2)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Bit_Rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tapsChannel
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset_0
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-80'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: excess_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: CMA
    num_taps: '15'
    sps: int(sps/2)
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: Time_BW
    max_dev: '1.5'
    osps: int(sps/2)
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 55e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '30'
    freq0: 99.5e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    name: '"Equalizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    name: '"Loop"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    name: '"PolyPhase"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: 99.5e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    name: '"Rx"'
    type: complex
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: 99.5e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    name: '"Rx"'
    type: complex
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.4'
    resample: '1'
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_1, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
