options:
  parameters:
    author: v-c
    generate_options: qt_gui
    id: QPSKPruebas1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bit_Rate
  id: variable
  parameters:
    comment: tasa de bits
    value: int(48e3)
  states: {}
- name: Bytes
  id: variable
  parameters:
    comment: Bytes a enviar
    value: int(Bit_Rate/8)
  states: {}
- name: CMA
  id: variable_adaptive_algorithm
  parameters:
    cons: QPSK
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: Delay
  id: variable_qtgui_range
  parameters:
    min_len: '500'
    outputmsgname: value
    showports: 'False'
    start: '1'
    step: '1'
    stop: '1000'
    value: '190'
    widget: counter
  states: {}
- name: Frec_offset
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '-0.1'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {}
- name: Freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 1e9
    step: 10e6
    stop: 3e9
    value: 2.7e9
    widget: counter
  states: {}
- name: M
  id: variable
  parameters:
    comment: '# Puntos de Constelacion'
    value: '4'
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: Symbol_Rate
  id: variable
  parameters:
    comment: tasa de simbolos
    value: Bit_Rate/bps
  states: {}
- name: Time_BW
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: 2*3.141592/100
  states: {}
- name: bps
  id: variable
  parameters:
    comment: Bits por simbolo
    value: math.log(M,2)
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Bit_Rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tapsChannel
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset_0
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Gitub\Documents\Tesis\audio2.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: 99.5e6
    gain0: '40'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2
    name: '"Tx"'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.4'
    resample: '1'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [digital_constellation_modulator_0, '0', osmosdr_sink_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
